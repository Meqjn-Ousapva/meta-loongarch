PV = "4.4.36"

SRC_URI:remove = " \
	file://0001-Make-BuildCommon.pm-compatible-with-latest-perl.patch \
	file://0002-Remove-smartmatch-usage-from-gen-crypt-h.patch \
	"

SRCREV = "f531a36aa916a22ef2ce7d270ba381e264250cbf"
