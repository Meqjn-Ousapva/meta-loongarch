RDEPENDS:${PN}:remove:loongarch64 = "kernel-img"
