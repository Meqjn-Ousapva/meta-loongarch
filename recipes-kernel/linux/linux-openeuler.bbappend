FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

OPENEULER_KERNEL_CONFIG = "file://loongson3_defconfig"

COMPATIBLE_MACHINE = "qemuloongarch64"
